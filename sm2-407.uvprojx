# Keil uVision project sm2-407.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: sm2-407 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group user
    ./User/: main.c uart.c fifobuff.c
  group common
    ./Common/: common.c
  group lib
    ./libmiracl/: mraes.c mralloc.c mrarth0.c mrarth1.c mrarth2.c mrarth3.c mrbits.c mrbrick.c mrbuild.c mrcore.c mrcrt.c mrcurve.c mrebrick.c mrec2m.c mrecn2.c mrfast.c mrfrnd.c mrgcd.c mrgcm.c mrgf2m.c mrio1.c mrio2.c mrjack.c mrlucas.c mrmonty.c mrpower.c mrprime.c mrrand.c mrround.c mrscrt.c mrshs.c mrshs256.c mrshs512.c mrsmall.c mrsroot.c mrstrong.c mrxgcd.c mrzzn2.c mrzzn2b.c mrzzn3.c
  group sm2
    ./sm2/: hexdump.c mtsm2.c sm2.c sm3.c
software components: CMSIS:CORE 5.3.0, Device:Startup 1.3.1, Device:StdPeriph Drivers:DMA 1.3.0, Device:StdPeriph Drivers:Framework 1.3.1, Device:StdPeriph Drivers:GPIO 1.3.0, Device:StdPeriph Drivers:RCC 1.3.0, Device:StdPeriph Drivers:USART 1.3.0
